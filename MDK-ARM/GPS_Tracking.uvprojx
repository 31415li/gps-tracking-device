# Keil uVision project GPS_Tracking.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPS_Tracking
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RTE_CMSIS_RTOS_RTX,STM32F10X_MD
  c include: ..\USER;..\USER\bsp;..\USER\thread;..\USER\sim808;..\USER\aes;..\USER\eeprom;..\USER\system;..\USER\flash;..\USER\record;..\USER\input
  memory RVCT4: ROM 0x8000000 size 0xf000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Objects\GPS_Tracking.sct
  group APP
    ../USER/: main.c app_cfg.h stm32f10x_it.c includes.h temp.txt HardFault_handler.c
  group BSP
    ../USER/bsp/: bsp.c spi_driver.c
  group Source
    ../USER/sim808/: sim808_driver.c sim808_app.c
    ../USER/aes/: aes.c
    ../USER/eeprom/: eeprom.c
    ../USER/system/: system.c
    ../USER/flash/: flash.c
    ../USER/record/: record.c
    ../USER/input/: input.c
  group Thread
    ../USER/thread/: Sim808_Thread.c App_Thread.c Position_Thread.c
software components: CMSIS:CORE 5.1.1, CMSIS:RTOS2:Keil RTX5 5.3.0, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
